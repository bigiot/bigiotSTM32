# Keil uVision project stm32f10x.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ebox +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\..\..\mcu\stm32f10x\libraries\CMSIS\CM3\CoreSupport;..\..\..\mcu\stm32f10x\libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\mcu\stm32f10x\libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\mcu\stm32f10x\ebox;..\..\..\mcu\stm32f10x\ebox\core;..\..\..\mcu\stm32f10x\ebox\Peripherals;..\..\..\common\util;..\..\..\common\edriver;..\..\..\common\network;..\..\..\common\fat;..\..\..\common\edriver\WiFi;..\..\..\user;..\..\..\common\cJSON;..\..\..\common\edriver\SFUD\sfud\inc;..\..\..\common\edriver\SFUD\ebox;..\..\..\common\bigiot
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group start_code
    ../../../mcu/stm32f10x/libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ../../../mcu/stm32f10x/libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../mcu/stm32f10x/libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group libraries
    ../../../mcu/stm32f10x/libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group ebox
    ../../../mcu/stm32f10x/ebox/: ebox.lib object.cpp
  group util
    ../../../common/util/: ebox_mem.c heap.c dtostrf.c itoa.c calendar.cpp color_convert.cpp ringbuf.cpp util.cpp WString.cpp print.cpp
  group edriver
    ../../../common/edriver/: 74HC595.cpp at24c02.cpp at45db.cpp Button.cpp colorled.cpp dht11.cpp DS3231.cpp encoder.cpp fm25v.cpp GP2Y1051.cpp ir_decoder.cpp ir_encoder.cpp key_dm.cpp L3G4200D.cpp lcd_1.8.cpp LCD1602.cpp LED.cpp led_segment.cpp lsm303dhlc.cpp LTC1446.cpp Max7456.cpp mmc_sd.cpp MPU6050.CPP Nokia5110.cpp NRF24L01.cpp OLED.cpp OLED_ssd1306.cpp parallel_gpio.cpp TM1638.cpp ultrasonic_wave.cpp w25x16.cpp w5500.cpp si4432.cpp
  group network
    ../../../common/network/: socket.cpp dhcp.cpp dns.cpp tcp.cpp udp.cpp
  group fat
    ../../../common/fat/: wrapperdiskio.cpp diskio.c ff.c
  group wifi
    ../../../common/edriver/WiFi/: ESP8266.cpp esp8266_tcp.cpp esp8266_udp.cpp
  group cJSON
    ../../../common/cJSON/: cJSON.c
  group sfud
    ../../../common/edriver/SFUD/sfud/src/: sfud.c sfud_sfdp.c
    ../../../common/edriver/SFUD/ebox/: ebox_sfud_port.cpp
  group BigIOT
    ../../../common/bigiot/: bigiot.cpp bigiot_port.cpp
  group user
    ../../../user/: main.cpp bsp.cpp
